# Repository soraneko0214/Calbo_ver3

## KiCad design hardware/raspcat.kicad_pcb

Parts:
C1: 220μ50V; CP_Radial_D8.0mm_P3.50mm
C2, C5, C6, C7: 0.1μ 25V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: 1μ 25V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CN1, CN2: CONN-SMD_HY2.0-4P
D1: LED_WHITE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D3, D4, D6: LED_RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: LED_BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: RB168MM-40; D_SOD-123F
D8: MMSZ4690T1G; D_SOD-123
F1: Fuse_Small; Fuseholder_Littelfuse_100_series_5x20mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
J2: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3, J4: st7735; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J5: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J6: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: Conn_01x03; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J9: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
JP1: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
Q1: 2SA1162GR; SC-59_Handsoldering
Q2: DTD123Y; SC-59_Handsoldering
R1, R2, R5: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 2.2M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R10: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R14, R16: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3, TP4, TP6, TP7, TP8, TP9: TestPoint_Small; TestPoint_Pad_D1.0mm
U1: R-78C5.0-1.0; Converter_DCDC_RECOM_R-78E-0.5_THT
U2: Pico; RPi_Pico_SMD_TH
U3: AP7333-33SGA; SOT-23_Handsoldering
U4: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U5: ULN2003A; DIP-16_W7.62mm_Socket_LongPads

Connections:
+3.3V: C4.1, C6.1, J3.7, J4.7, J5.2, J6.1, Q1.2 (E), R1.1, R2.1, R8.2, R9.2, TP3.1, U3.2 (VO), U4.8 (VCC)
+5V: C3.1, C5.2, C7.2, CN1.2, CN2.2, D8.1 (K), J9.5, R7.1, R11.1, R12.1, R14.1, R16.1, TP2.1, U1.3 (OUT), U2.39 (VSYS), U3.1 (VI), U5.9 (COM)
+12V: C2.1, J8.2, R3.2, R15.1, R17.2, TP1.1, U1.1 (IN)
CLK: J3.6, J4.6, U2.24 (GPIO18)
CS1: J3.2, U2.17 (GPIO13)
CS2: J4.2, U2.16 (GPIO12)
Capacitive: J5.1, U2.14 (GPIO10)
Cds: J6.2, R5.1, TP9.1, U2.31 (GPIO26_ADC0)
DC: J3.3, J4.3, U2.34 (GPIO28_ADC2)
DebugLED: Q2.1 (B), U2.19 (GPIO14)
GND: C3.2, C4.2, C5.1, C6.2, C7.1, CN1.1, CN2.1, D5.1 (K), D8.2 (A), J3.8, J4.8, J5.3, JP1.2 (B), Q2.2 (E), R5.2, R6.1, R10.1, U1.2 (GND), U2.3 (GND), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.38 (GND), U3.3 (GND), U4.5 (GND), U5.8 (GND)
GNDPWR: C1.2, C2.2, J1.2, J8.1, JP1.1 (A), R3.1
M5_SCL: CN1.4, R1.2, TP7.1, U2.2 (GPIO1)
M5_SDA: CN1.3, R2.2, TP8.1, U2.1 (GPIO0)
unnamed: D1.2 (A), R7.2
unnamed: D1.1 (K), Q2.3 (C)
unnamed: D2.2 (A), R11.2
unnamed: D2.1 (K), J9.1, U5.16 (O1)
unnamed: D3.2 (A), R12.2
unnamed: D3.1 (K), J9.2, U5.15 (O2)
unnamed: D4.2 (A), R14.2
unnamed: D4.1 (K), J9.3, U5.14 (O3)
unnamed: D5.2 (A), R15.2
unnamed: D6.2 (A), R16.2
unnamed: D6.1 (K), J9.4, U5.13 (O4)
unnamed: C1.1, D7.2 (A), J2.1
unnamed: D7.1 (K), R17.1
unnamed: F1.1, J1.1
unnamed: F1.2, J2.2
unnamed: J8.3, R8.1, TP6.1, U4.6 (A)
unnamed: Q1.1 (B), R4.2
unnamed: Q1.3 (C), R6.2, U4.2 (~RE), U4.3 (DE)
unnamed: R9.1, R10.2, U4.7 (B)
unnamed: CN2.3, U4.1 (RO)
RST: J3.4, J4.4, U2.29 (GPIO22)
SDA: J3.5, J4.5, U2.25 (GPIO19)
STEP_IN1: U2.12 (GPIO9), U5.1 (I1)
STEP_IN2: U2.11 (GPIO8), U5.2 (I2)
STEP_IN3: U2.10 (GPIO7), U5.3 (I3)
STEP_IN4: U2.9 (GPIO6), U5.4 (I4)
STS_Tx: CN2.4, R4.1, TP4.1, U4.4 (DI)

Notes on the sheet:
C6:0.1uF~1.0Fで波形調整
電源回路
デバッグLED
C1起点で接続する
Dynamixel_TTL
right_eyedisplay
Dynamixel_UART-TTL回路
マイコン周辺回路
電源スイッチ
静電容量タッチスイッチ
M5stack_I2C
ステッピングモータ
12v_LED
left_eyedisplay
照度センサ
R8:2.2k~10kで波形調整(10k低応答)
9V~12V電源入力

Board: 2 copper layers, 70.0 x 70.0 mm, 62 parts (9 on the bottom side), 41 nets.

File hardware/jlcpcb/production_files/BOM-raspcat.csv:

Comment,Designator,Footprint,LCSC
Conn_01x03,J5,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,C144394
0.1μ 25V,"C2,C5,C6,C7",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663
AP7333-33SGA,U3,SOT-23_Handsoldering,C150746
MMSZ4690T1G,D8,D_SOD-123,C152307
2SA1162GR,Q1,SC-59_Handsoldering,C155455
Conn_01x02,J2,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,C157931
st7735,"J3,J4",JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical,C157972
Conn_01x05,J9,JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,C157991
Conn_01x02,J6,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,C158012
1μ 25V,"C3,C4",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849
R-78C5.0-1.0,U1,Converter_DCDC_RECOM_R-78E-0.5_THT,C18212367
ULN2003A,U5,DIP-16_W7.62mm_Socket_LongPads,C18723564
1k,R15,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C21190
LED_RED,"D2,D3,D4,D6",LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C2286
LED_BLUE,D5,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C2290
2.2M,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22938
330,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23138
470,"R11,R12,R14,R16",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23179
7.5k,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23234
10k,"R1,R2,R5,R8,R9",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25804
Conn_01x03,J8,JST_EH_S3B-EH_1x03_P2.50mm_Horizontal,C263754
220μ50V,C1,CP_Radial_D8.0mm_P3.50mm,C2836445
Barrel_Jack_Switch,J1,BarrelJack_Horizontal,C319099
20k,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C4184
2.2k,R10,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C4190
10,R17,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C441940
RB168MM-40,D7,D_SOD-123F,C509936
MAX3485,U4,SOP-8_3.9x4.9mm_P1.27mm,C558792
~,"CN1,CN2",CONN-SMD_HY2.0-4P,C722729
DTD123Y,Q2,SC-59_Handsoldering,C919455
Pico,U2,RPi_Pico_SMD_TH,
Fuse_Small,F1,Fuseholder_Littelfuse_100_series_5x20mm,
LED_WHITE,D1,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
TestPoint_Small,TP1,TestPoint_Pad_D1.0mm,
TestPoint_Small,TP8,TestPoint_Pad_D1.0mm,
TestPoint_Small,TP3,TestPoint_Pad_D1.0mm,
TestPoint_Small,TP7,TestPoint_Pad_D1.0mm,
TestPoint_Small,TP6,TestPoint_Pad_D1.0mm,
TestPoint_Small,TP4,TestPoint_Pad_D1.0mm,
Jumper_2_Bridged,JP1,SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm,
TestPoint_Small,TP9,TestPoint_Pad_D1.0mm,
TestPoint_Small,TP2,TestPoint_Pad_D1.0mm,

## Commit log

2024-09-06 jlcpcb用ガーバデータ修正
2024-09-11 JLCPCB用部品割り当て修正
2024-09-14 latest version
